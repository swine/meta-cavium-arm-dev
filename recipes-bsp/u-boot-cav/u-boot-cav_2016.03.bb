include u-boot-cav.inc

DEPENDS += "dtc-native"


